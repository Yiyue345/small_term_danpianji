# Keil uVision project 智能电压监控系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 12 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c keyboard.c smg.c ls138.c main.c delay.h ds1302.c I2C.c
